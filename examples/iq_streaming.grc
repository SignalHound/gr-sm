options:
  parameters:
    author: Signal Hound
    generate_options: qt_gui
    id: iq_streaming
    output_language: python
    title: SM I/Q Streaming
  states: {}

blocks:
- name: bandwidth_entry
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0
    label: Bandwidth
    start: 1e6
    step: 1e3
    stop: 41.5e6
    value: 20e6
    widget: counter
  states: {}
- name: center_entry
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Center Frequency
    start: 100e3
    step: 100e6
    stop: 20e9
    value: 1e9
  states: {}
- name: decimation_entry
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0
    label: Decimation
    labels: '[]'
    num_opts: '0'
    options: '[1,2,4,8,16,32,64,128,256,512,1024,2048,4096]'
    type: int
    value: '2'
  states: {}
- name: filter_entry
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4,0
    label: Software Filter
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: purge_entry
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 5,0
    label: Purge
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: reflevel_entry
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Reference Level
    start: '-80'
    step: '1'
    stop: '20'
    value: '-20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200.0e6 / decimation_entry
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 32e3
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_entry
    fftsize: '1024'
    rate: '1000'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: sm_iq_0
  id: sm_iq
  parameters:
    bandwidth: bandwidth_entry
    center: center_entry
    decimation: decimation_entry
    filter: filter_entry
    networked: 'False'
    purge: purge_entry
    reflevel: reflevel_entry
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [sm_iq_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
